# Keil uVision project PinLv.uvprojx, settings and files
target PinLv (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\CORE;..\USER;..\SYSTEM;..\SYSTEM\delay;..\STM32F0xx_FWLib\inc;..\STM32F0xx_FWLib\src;..\HARDWARE\LED;..\HARDWARE\IWDG;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\mcu_sdk;..\SYSTEM\sys;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\SHT20;..\HARDWARE\POWER;..\HARDWARE\USART1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f0xx_ld.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SHT20/: SHT2x.c
    ../HARDWARE/POWER/: pwr.c
    ../HARDWARE/USART1/: USART1.c
  group FWLIB
    ../STM32F0xx_FWLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group TUYA
    ../mcu_sdk/: mcu_api.c protocol.c system.c
